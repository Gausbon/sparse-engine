# Keil uVision project uartRev1.uvprojx, settings and files
target uartRev1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.1
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: uartRev1
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Core/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c quantization_inference.c result_check.c
  group Application/User/Core/CMSIS_append
    ../Core/Src/cmsis_append/: arm_convolve_s8_sparse.c arm_depthwise_conv_s8_sparse.c arm_fully_connected_s8_sparse.c arm_nn_batch_mat_mult_nt_t_s8.c arm_nn_batch_mat_mult_s8.c arm_nn_layernorm_s8.c arm_nn_output_per_channel.c arm_nn_softmax_common_s8.c arm_nn_sparse_decode.c arm_pool_s8_with_quantization.c arm_nn_transpose_bnc_to_nbc_q7.c arm_elementwise_add_s8_with_neg.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Core/Src/: system_stm32f7xx.c
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, CMSIS:NN Lib 3.1.0, Compiler:I/O:STDOUT 1.2.0
